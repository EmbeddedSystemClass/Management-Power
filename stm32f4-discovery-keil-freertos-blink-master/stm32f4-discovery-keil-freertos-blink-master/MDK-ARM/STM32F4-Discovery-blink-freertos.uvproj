# Keil uVision project STM32F4-Discovery-blink-freertos.uvproj, settings and files
target stm32f4_blink_freertos (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: bin +hex
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\startup;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c
    ../STM32F4_Discovery/: io.c flash.c gsm.c printf.c rtc.c bq32000.c lcd.c rf.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_i2c.c
  group Discovery
    ../STM32F4_Discovery/: discoveryf4utils.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/: FreeRTOSConfig.h
    ../FreeRTOS/Source/include/: semphr.h timers.h portable.h
  group startup
    ../startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group Lib
    ../: main.h
    ../STM32F4_Discovery/: gsm.h bq32000.h io.h uprintf.h rtc.h flash.h discoveryf4utils.h lcd.h rf.h
